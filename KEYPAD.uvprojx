# Keil uVision project KEYPAD.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KEYPAD
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: DEBUG GD32F10X_MD
  c include: .\CANopenNode;.\CANopenNode\301;.\CANopenNode\303;.\CANopenNode\304;.\CANopenNode\305;.\CANopenNode\309;.\CANopenNode\keypad;..\GD_KEYPAD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c main.h CanOpenNode.c process.c
  group CanOpenNode
    ./CANopenNode/keypad/: CO_driver_ST32F103.c CO_driver_ST32F103.h CO_driver_target.h OD.c
    ./CANopenNode/301/: CO_ODinterface.c CO_config.h CO_driver.h CO_Emergency.c CO_Emergency.h CO_fifo.c CO_fifo.h CO_HBconsumer.c CO_HBconsumer.h CO_NMT_Heartbeat.c CO_NMT_Heartbeat.h CO_ODinterface.h CO_PDO.c CO_PDO.h CO_SDOclient.c CO_SDOclient.h CO_SDOserver.c CO_SDOserver.h CO_SYNC.c CO_SYNC.h CO_TIME.c CO_TIME.h crc16-ccitt.c crc16-ccitt.h
    ./CANopenNode/: CANopen.h CANopen.c
    ./CANopenNode/305/: CO_LSS.h CO_LSSmaster.c CO_LSSmaster.h CO_LSSslave.c CO_LSSslave.h
  group Driver
    ./: flash_data.c led.c init.c init.h keyboard.c keyboard.h gd32f10x_it.c gd32f10x_it.h systick.c systick.h
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.5.1, Device:GD32F10x_StdPeripherals:CAN 2.2.4, Device:GD32F10x_StdPeripherals:DBG 2.2.4, Device:GD32F10x_StdPeripherals:FMC 2.2.4, Device:GD32F10x_StdPeripherals:FWDGT 2.2.4, Device:GD32F10x_StdPeripherals:GPIO 2.2.4, Device:GD32F10x_StdPeripherals:MISC 2.2.4, Device:GD32F10x_StdPeripherals:PMU 2.2.4, Device:GD32F10x_StdPeripherals:RCU 2.2.4, Device:GD32F10x_StdPeripherals:SPI_I2S 2.2.4, Device:GD32F10x_StdPeripherals:TIMER 2.2.4, Device:GD32F10x_libopt 2.2.4, Device:Startup 2.2.4
